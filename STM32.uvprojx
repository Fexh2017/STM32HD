# Keil uVision project STM32.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\user;.\user\includes;.\user\includes\BSP;.\user\includes\peripherals;.\user\includes\peripherals\USB\USB_CORE;.\user\includes\peripherals\USB\USB_CONFIG;.\user\includes\peripherals\USB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group src
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_wwdg.c
  group sys
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group includes
    ./user/includes/: stm32f10x_conf.h stm32f10x_it.h config.h public.h
  group main
    ./user/main/: main.c public.c stm32f10x_it.c
  group peripherals
    ./user/peripherals/: p_debug.c p_led.c p_usb.c
  group BSP
    ./user/BSP/: f_rcc.c f_gpio.c f_usart.c f_timer.c f_dma.c f_adc.c f_dac.c f_nvic.c f_usb.c
  group USB_PROPERTY
    ./user/peripherals/USB/: usb_Joystick.c
